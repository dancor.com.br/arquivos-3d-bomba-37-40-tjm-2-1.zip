Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: W:\PRODUTOS\SERIE CAM\37-40\IFC\BOMBA 37-40 TJM 2.1-'' 7,5CV T 4V INC IR3.IFC
Time: 2026-06-09T12:34:51+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project
